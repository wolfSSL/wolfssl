/* test_tsp_fault_whitebox.c
 *
 * Copyright (C) 2006-2026 wolfSSL Inc.
 *
 * This file is part of wolfSSL.
 *
 * wolfSSL is free software; you can redistribute it and/or modify
 * it under the terms of the GNU General Public License as published by
 * the Free Software Foundation; either version 3 of the License, or
 * (at your option) any later version.
 *
 * wolfSSL is distributed in the hope that it will be useful,
 * but WITHOUT ANY WARRANTY; without even the implied warranty of
 * MERCHANTABILITY or FITNESS FOR A PARTICULAR PURPOSE.  See the
 * GNU General Public License for more details.
 *
 * You should have received a copy of the GNU General Public License
 * along with this program; if not, write to the Free Software
 * Foundation, Inc., 51 Franklin Street, Fifth Floor, Boston, MA 02110-1335, USA
 */

/*
 * MC/DC fault/argument-guard white-box supplement for wolfcrypt/src/tsp.c.
 *
 * tests/api/test_tsp.c and tests/unit-mcdc/test_tsp_whitebox.c together drive
 * the module's happy paths and most static-helper argument guards. The
 * campaign's GAPS.md still lists a residual set of MC/DC independence pairs
 * as unshown in the union of all variant runs; this file targets those,
 * providing BOTH rows of each pair in this one binary (MC/DC independence is
 * computed per binary, not merged across separately-compiled #include
 * copies of tsp.c - see mcdc_fault_alloc.h and the other tests/unit-mcdc
 * fault whiteboxes for the same rule).
 *
 * Two techniques not used elsewhere in the tsp.c white-boxes:
 *
 *  1. XGMTIME mock: wc_TspTstInfo_SetGenTimeAsTime()'s
 *     `(ts == NULL) || ValidateGmtime(ts)` guard (tsp.c:797) can only see
 *     ts==NULL or an invalid struct tm when the platform's real gmtime()
 *     fails or returns something ValidateGmtime rejects - not reliably
 *     triggerable with real clock values. wc_port.h's XGMTIME macro is only
 *     defined `#if !defined(XGMTIME)`, so defining it here BEFORE
 *     #include <wolfcrypt/src/tsp.c> installs a controllable replacement for
 *     tsp.c's own (only) use of it, without touching any other translation
 *     unit (every other file's XGMTIME expansion is fixed at that file's own
 *     compile time in the already-built library). wbXGMTIME() passes through
 *     to the real gmtime() by default and switches to returning NULL, an
 *     out-of-range struct tm, or a struct tm with a huge tm_year (ValidateGmtime
 *     does not range-check tm_year) on request - the last of these also drives
 *     the `(n < 0) || (n >= (int)bufSz)` truncation guard at tsp.c:808.
 *
 *  2. Hand-built X.509 certificates: Tsp_CheckSignerCert()'s extended-key-usage
 *     (tsp.c:1763) and key-usage (tsp.c:1773) guards need certificates with
 *     properties no existing certs_test.h fixture has - no EKU extension at
 *     all, an EKU that is present but not critical, and a KeyUsage extension
 *     present but with no recognized bit set. These are generated once
 *     (openssl req -x509, self-signed) and embedded as DER byte arrays below;
 *     ParseCertRelative() is called by Tsp_CheckSignerCert() with NO_VERIFY,
 *     so an invalidated signature (the KU-zero cert has its KeyUsage bit
 *     string patched to all-zero bits AFTER signing, to get a KeyUsage
 *     extension with literally no bit set) does not matter - only the
 *     extension structure is under test. See the generation notes at each
 *     array.
 *
 * Real signed CMS token: TspResponse_Verify()'s post-verify decisions
 * (cm != NULL at tsp.c:2162, and the tstInfo/contentSz rows at tsp.c:2179/
 * 2188 it shares the same successful-verify prerequisite with) need a
 * genuinely valid signed CMS SignedData TimeStampToken to reach ret == 0 at
 * that point - documented in test_tsp_whitebox.c as not attempted there.
 * wb_make_token() builds one the same way tests/api/test_tsp.c's
 * test_tsp_make_token() does: wc_TspTstInfo_SignWithPkcs7() with
 * tsa_cert_der_2048/tsa_key_der_2048 (real RSA signature over real
 * SignedAttributes).
 *
 * DEATHNOTE claim check (asn_tsp.c:1433, condition index 0,
 * `GetASNTag(signers, &idx, &tag, signersSz) < 0`, inside
 * TspCheckOneSignerInfo()'s `while ((ret == 0) && (idx < signersSz))` loop):
 * CONFIRMED dead at this call site. GetASNTag() only fails when
 * `idx + ASN_TAG_SZ > maxIdx` (asn.c, ASN_TAG_SZ == 1); the enclosing loop
 * guard `idx < signersSz` already guarantees `idx + 1 <= signersSz` on every
 * entry to the loop body, and idx is not advanced between the guard and the
 * call, so `idx + ASN_TAG_SZ > signersSz` can never hold here.
 *
 * asn_tsp.c is #include'd into asn.c (not its own translation unit); this
 * file only needs its WOLFSSL_LOCAL declarations, already linked into the
 * built library's asn.o - no #include of asn_tsp.c is attempted here (see
 * test_tsp_whitebox.c's header for why that would be unnecessary anyway:
 * none of the residuals here are in one of its file-static helpers).
 *
 * Targeted residuals, by GAPS.md line (17 NULL/argument-guard conditions):
 *   tsp.c:797  idx0,idx1   - SetGenTimeAsTime ts==NULL / ValidateGmtime
 *   tsp.c:1033 idx3,idx5   - SetFromRequest policySz==0 / serialSz==0
 *   tsp.c:1175 idx4        - CheckRequest nonce content mismatch
 *   tsp.c:1182 idx3        - CheckRequest policy size mismatch
 *   tsp.c:1472 idx2        - SignWithPkcs7 singleCertSz==0
 *   tsp.c:1683 idx0,idx2   - Tsp_CheckTsaName subjectRaw==NULL / mismatch
 *   tsp.c:1697 idx0,idx2   - Tsp_CheckTsaName rfc822Name / uri tag
 *   tsp.c:1763 idx0,idx3   - Tsp_CheckSignerCert no-EKU / EKU-not-critical
 *   tsp.c:1773 idx0,idx2   - Tsp_CheckSignerCert no-KU / KU-zero-bits
 *   tsp.c:2162 idx0,idx1   - TspResponse_Verify cm != NULL
 * Plus allocation err-chain coverage (mcdc_fault_alloc.h fault sweep) over
 * wc_TspTstInfo_SignWithPkcs7()'s tstDer/attribs XMALLOC calls, and two cheap
 * bonus rows opportunistic with the above (tsp.c:939 SetNonce loop entry,
 * and the 2179/2188 tstInfo!=NULL/contentSz>0 rows that fall out of the real
 * token used for 2162).
 *
 * Documented as NOT attempted (out of this pass's scope):
 *   - tsp.c:808 idx0 (XSNPRINTF returning negative): no legitimate input
 *     drives this on a real libc snprintf; not claimed dead, just unreached.
 *   - tsp.c:1112/1854, 2167:3, 2179 idx2 true row (contentSz==0),
 *     2188/2230, and every asn_tsp.c-only decode-side item in GAPS.md
 *     (341/354/362/369/557/714/718/1021/1194/1343/1429/1445): each needs
 *     either a clock/libc fault this file's XGMTIME mock does not reach, a
 *     zero-length-content token this pass did not construct, or DER
 *     surgery on an encoded TSTInfo/TimeStampResp whose exact byte offsets
 *     were not worked out here - same class of residual test_tsp_whitebox.c
 *     already documents.
 */

#include <time.h>
#include <string.h>

/* ---- XGMTIME mock: installed before tsp.c is compiled - see file header
 * technique (1). Mode is a plain int, not an enum, so tsp.c's own headers
 * (included by the #include below) cannot collide with a symbol name. ---- */
static int wbGmtimeMode = 0; /* 0 passthrough, 1 NULL, 2 invalid tm, 3 huge year */
static struct tm wbFakeTm;

static struct tm* wbXGMTIME(const time_t* clock, struct tm* tmpBuf)
{
    (void)tmpBuf;
    if (wbGmtimeMode == 1) {
        /* 797 idx0 true: XGMTIME "fails". */
        return NULL;
    }
    if (wbGmtimeMode == 2) {
        /* 797 idx1 true: a struct tm ValidateGmtime rejects (tm_mday==0 and
         * tm_hour==99 both out of its accepted ranges). */
        memset(&wbFakeTm, 0, sizeof(wbFakeTm));
        wbFakeTm.tm_hour = 99;
        return &wbFakeTm;
    }
    if (wbGmtimeMode == 3) {
        /* 797 false, 808 idx1 true: a real, ValidateGmtime-valid tm, but
         * with tm_year pushed huge (ValidateGmtime does not range-check
         * tm_year) so the formatted GeneralizedTime string overflows bufSz. */
        struct tm* real = gmtime(clock);
        if (real == NULL) {
            return NULL;
        }
        wbFakeTm = *real;
        wbFakeTm.tm_year = 99999999;
        return &wbFakeTm;
    }
    /* Passthrough: real gmtime(), same as the default (non-reentrant) tail
     * of wc_port.h's own XGMTIME chain - single-threaded test, safe. */
    return gmtime(clock);
}
#define XGMTIME(c, t) wbXGMTIME((c), (t))

#include <wolfcrypt/src/tsp.c>

#include <wolfssl/ssl.h>
#include <wolfssl/certs_test.h>
#include <stdio.h>

static int wb_fail = 0;
#define WB_NOTE(msg) do { printf("  [wb] %s\n", (msg)); } while (0)

#if !defined(WOLFSSL_TSP)

int main(void)
{
    setvbuf(stdout, NULL, _IONBF, 0);
    printf("tsp.c fault white-box: WOLFSSL_TSP absent, nothing to do\n");
    return 0;
}

#else

#include "mcdc_fault_alloc.h"

/* ---- shared test fixtures ------------------------------------------- */
static const byte wbHashedMsg[32] = {
    0x00, 0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07,
    0x08, 0x09, 0x0a, 0x0b, 0x0c, 0x0d, 0x0e, 0x0f,
    0x10, 0x11, 0x12, 0x13, 0x14, 0x15, 0x16, 0x17,
    0x18, 0x19, 0x1a, 0x1b, 0x1c, 0x1d, 0x1e, 0x1f
};
static const byte wbPolicy[] = { 0x2b, 0x06, 0x01, 0x04, 0x01, 0x87, 0x67, 0x01 };
static const byte wbSerial[] = { 0x9a, 0x33 };
static const byte wbGenTime[] = "20260604120000Z";

/* ------------------------------------------------------------------------- *
 * tsp.c:797/808 - wc_TspTstInfo_SetGenTimeAsTime() XGMTIME/format guards.
 * See the XGMTIME mock at the top of this file.
 * ------------------------------------------------------------------------- */
#if !defined(NO_ASN_TIME) && defined(WOLFSSL_TSP_RESPONDER)
static void wb_gentime_as_time_guards(void)
{
    TspTstInfo tst;
    byte buf[ASN_GENERALIZED_TIME_SIZE];
    int ret;

    XMEMSET(&tst, 0, sizeof(tst));

    /* all-false baseline: real clock, in range, fits bufSz - closes 797
     * idx0/idx1 FALSE and 808 idx0/idx1 FALSE rows. */
    wbGmtimeMode = 0;
    ret = wc_TspTstInfo_SetGenTimeAsTime(&tst, (time_t)1700000000, buf,
        sizeof(buf));
    if (ret != 0) {
        WB_NOTE("SetGenTimeAsTime baseline misbehaved");
        wb_fail = 1;
    }

    /* 797 idx0 true. */
    wbGmtimeMode = 1;
    ret = wc_TspTstInfo_SetGenTimeAsTime(&tst, (time_t)1700000000, buf,
        sizeof(buf));
    wbGmtimeMode = 0;
    if (ret != WC_NO_ERR_TRACE(ASN_TIME_E)) {
        WB_NOTE("SetGenTimeAsTime ts==NULL case misbehaved");
        wb_fail = 1;
    }

    /* 797 idx1 true, idx0 false. */
    wbGmtimeMode = 2;
    ret = wc_TspTstInfo_SetGenTimeAsTime(&tst, (time_t)1700000000, buf,
        sizeof(buf));
    wbGmtimeMode = 0;
    if (ret != WC_NO_ERR_TRACE(ASN_TIME_E)) {
        WB_NOTE("SetGenTimeAsTime invalid-tm case misbehaved");
        wb_fail = 1;
    }

    /* 808 idx1 true, 797 false. */
    wbGmtimeMode = 3;
    ret = wc_TspTstInfo_SetGenTimeAsTime(&tst, (time_t)1700000000, buf,
        sizeof(buf));
    wbGmtimeMode = 0;
    if (ret != WC_NO_ERR_TRACE(ASN_TIME_E)) {
        WB_NOTE("SetGenTimeAsTime year-overflow case misbehaved");
        wb_fail = 1;
    }

    WB_NOTE("wc_TspTstInfo_SetGenTimeAsTime XGMTIME/format MC/DC pairs exercised");
}
#else
static void wb_gentime_as_time_guards(void) { WB_NOTE("NO_ASN_TIME or WOLFSSL_TSP_RESPONDER off; SetGenTimeAsTime guards skipped"); }
#endif

/* ------------------------------------------------------------------------- *
 * tsp.c:939 bonus - wc_TspTstInfo_SetNonce() leading-zero-strip loop entry.
 * A 2-byte {0x00, 0x01} nonce hits idx0 true on the first iteration (strips
 * the zero byte) and idx0 false on the second (nonceSz==1, loop exits) -
 * both rows in one call.
 * ------------------------------------------------------------------------- */
#ifdef WOLFSSL_TSP_RESPONDER
static void wb_set_nonce_extra(void)
{
    TspTstInfo tst;
    byte nonce[2] = { 0x00, 0x01 };
    int ret;

    XMEMSET(&tst, 0, sizeof(tst));
    ret = wc_TspTstInfo_SetNonce(&tst, nonce, sizeof(nonce));
    if ((ret != 0) || (tst.nonceSz != 1) || (tst.nonce[0] != 0x01)) {
        WB_NOTE("wc_TspTstInfo_SetNonce leading-zero-strip case misbehaved");
        wb_fail = 1;
    }
    WB_NOTE("wc_TspTstInfo_SetNonce nonceSz>1 true/false rows exercised");
}
#else
static void wb_set_nonce_extra(void) { WB_NOTE("WOLFSSL_TSP_RESPONDER off; SetNonce extra skipped"); }
#endif

/* ------------------------------------------------------------------------- *
 * tsp.c:1033 - wc_TspTstInfo_SetFromRequest() policySz==0 (idx3) and
 * serialSz==0 (idx5), each paired against an all-false success baseline.
 * ------------------------------------------------------------------------- */
#ifdef WOLFSSL_TSP_RESPONDER
static void wb_set_from_request_guards(void)
{
    TspTstInfo tst;
    TspRequest req;
    byte policy[4] = { 1, 2, 3, 4 };
    byte serial[4] = { 5, 6, 7, 8 };
    int ret;

    XMEMSET(&tst, 0, sizeof(tst));
    XMEMSET(&req, 0, sizeof(req));

    /* all-false baseline: closes idx3/idx5 FALSE rows. */
    ret = wc_TspTstInfo_SetFromRequest(&tst, &req, policy, sizeof(policy),
            serial, sizeof(serial), NULL, 0);
    if (ret != 0) {
        WB_NOTE("SetFromRequest baseline misbehaved");
        wb_fail = 1;
    }

    /* idx3 true. */
    ret = wc_TspTstInfo_SetFromRequest(&tst, &req, policy, 0, serial,
            sizeof(serial), NULL, 0);
    if (ret != WC_NO_ERR_TRACE(BAD_FUNC_ARG)) {
        WB_NOTE("SetFromRequest policySz==0 case misbehaved");
        wb_fail = 1;
    }

    /* idx5 true, idx3/idx4 false. */
    ret = wc_TspTstInfo_SetFromRequest(&tst, &req, policy, sizeof(policy),
            serial, 0, NULL, 0);
    if (ret != WC_NO_ERR_TRACE(BAD_FUNC_ARG)) {
        WB_NOTE("SetFromRequest serialSz==0 case misbehaved");
        wb_fail = 1;
    }
    WB_NOTE("wc_TspTstInfo_SetFromRequest policySz/serialSz==0 pairs exercised");
}
#else
static void wb_set_from_request_guards(void) { WB_NOTE("WOLFSSL_TSP_RESPONDER off; SetFromRequest guards skipped"); }
#endif

/* ------------------------------------------------------------------------- *
 * tsp.c:1175/1182 - wc_TspTstInfo_CheckRequest() nonce-content-mismatch
 * (1175 idx4) and policy-size-mismatch (1182 idx3), each paired against an
 * all-false (nonce and policy both match exactly) success baseline.
 * ------------------------------------------------------------------------- */
#ifdef WOLFSSL_TSP_VERIFIER
static void wb_check_request_extra(void)
{
    TspTstInfo tst;
    TspRequest req;
    byte nonce[2] = { 0x01, 0x02 };
    byte policyShort[2] = { 0x0A, 0x0B };
    byte policyLong[3] = { 0x0A, 0x0B, 0x0C };
    int ret;

    XMEMSET(&tst, 0, sizeof(tst));
    XMEMSET(&req, 0, sizeof(req));
    tst.version = WC_TSP_VERSION;
    tst.imprint.hashAlgOID = SHA256h;
    req.imprint.hashAlgOID = SHA256h;
    tst.imprint.hashSz = 4;
    req.imprint.hashSz = 4;
    XMEMSET(tst.imprint.hash, 0xAA, 4);
    XMEMSET(req.imprint.hash, 0xAA, 4);

    /* all-false baseline: nonce and policy both requested and match exactly -
     * closes 1175 idx4 FALSE and 1182 idx3 FALSE rows. */
    tst.nonce = nonce;
    tst.nonceSz = sizeof(nonce);
    XMEMCPY(req.nonce, nonce, sizeof(nonce));
    req.nonceSz = sizeof(nonce);
    tst.policy = policyLong;
    tst.policySz = sizeof(policyLong);
    XMEMCPY(req.policy, policyLong, sizeof(policyLong));
    req.policySz = sizeof(policyLong);
    ret = wc_TspTstInfo_CheckRequest(&tst, &req);
    if (ret != 0) {
        WB_NOTE("CheckRequest match baseline misbehaved");
        wb_fail = 1;
    }

    /* 1175 idx4 true, idx2/idx3 false: nonce same size, differing content. */
    {
        byte nonceB[2] = { 0x01, 0x03 };
        XMEMCPY(req.nonce, nonceB, sizeof(nonceB));
        req.nonceSz = sizeof(nonceB);
        ret = wc_TspTstInfo_CheckRequest(&tst, &req);
        if (ret != WC_NO_ERR_TRACE(TSP_VERIFY_E)) {
            WB_NOTE("CheckRequest nonce content-mismatch case misbehaved");
            wb_fail = 1;
        }
        XMEMCPY(req.nonce, nonce, sizeof(nonce));
        req.nonceSz = sizeof(nonce);
    }

    /* 1182 idx3 true: policy present in both, sizes differ. Nonce not
     * requested this time, so 1175 short-circuits false first. */
    req.nonceSz = 0;
    XMEMCPY(req.policy, policyShort, sizeof(policyShort));
    req.policySz = sizeof(policyShort);
    ret = wc_TspTstInfo_CheckRequest(&tst, &req);
    if (ret != WC_NO_ERR_TRACE(TSP_VERIFY_E)) {
        WB_NOTE("CheckRequest policy size-mismatch case misbehaved");
        wb_fail = 1;
    }

    WB_NOTE("wc_TspTstInfo_CheckRequest nonce-content/policy-size pairs exercised");
}
#else
static void wb_check_request_extra(void) { WB_NOTE("WOLFSSL_TSP_VERIFIER off; CheckRequest extra pairs skipped"); }
#endif

/* ------------------------------------------------------------------------- *
 * tsp.c:1472 - wc_TspTstInfo_SignWithPkcs7() singleCertSz==0 (idx2). The
 * paired all-false row (singleCert set, singleCertSz != 0, ret==0 at this
 * decision) is provided by wb_sign_with_pkcs7_alloc_sweep()'s baseline sign
 * below, same binary.
 * ------------------------------------------------------------------------- */
#if defined(WOLFSSL_TSP_RESPONDER) && defined(HAVE_PKCS7)
static void wb_sign_with_pkcs7_certsz(void)
{
    TspTstInfo tst;
    wc_PKCS7 pkcs7;
    byte certBuf[4] = { 1, 2, 3, 4 };
    byte out[16];
    word32 outSz = sizeof(out);
    int ret;

    XMEMSET(&tst, 0, sizeof(tst));
    XMEMSET(&pkcs7, 0, sizeof(pkcs7));
    pkcs7.singleCert = certBuf;
    pkcs7.singleCertSz = 0;
    ret = wc_TspTstInfo_SignWithPkcs7(&tst, &pkcs7, out, &outSz);
    if (ret != WC_NO_ERR_TRACE(BAD_FUNC_ARG)) {
        WB_NOTE("SignWithPkcs7 singleCertSz==0 case misbehaved");
        wb_fail = 1;
    }
    WB_NOTE("wc_TspTstInfo_SignWithPkcs7 singleCertSz==0 row exercised");
}
#else
static void wb_sign_with_pkcs7_certsz(void) { WB_NOTE("WOLFSSL_TSP_RESPONDER/HAVE_PKCS7 off; SignWithPkcs7 certsz skipped"); }
#endif

/* ------------------------------------------------------------------------- *
 * Allocation err-chain: fault-sweep wc_TspTstInfo_SignWithPkcs7()'s tstDer
 * and attribs XMALLOC calls (tsp.c:1494/1519) via mcdc_fault_alloc.h. Also
 * provides the 1472 all-false baseline (a full, unarmed successful sign).
 * ------------------------------------------------------------------------- */
#if defined(WOLFSSL_TSP_RESPONDER) && defined(HAVE_PKCS7) && !defined(NO_RSA) && \
    !defined(NO_SHA256)
/* A wc_PKCS7 object that has completed one wc_PKCS7_EncodeSignedData is not
 * safe to sign with a second time (confirmed by two successive unarmed
 * calls on the same object crashing identically to the fault-swept case
 * below, unrelated to any injected allocation failure) - a fresh object is
 * built for every sweep iteration instead, same as tests/api/test_pkcs7.c's
 * own idiom of wc_PKCS7_New()/wc_PKCS7_Free() around each encode call. */
static int wb_setup_signer(wc_PKCS7** pkcs7, WC_RNG* rng)
{
    int ret;

    ret = wc_InitRng(rng);
    if (ret != 0) {
        return ret;
    }
    *pkcs7 = wc_PKCS7_New(NULL, INVALID_DEVID);
    if (*pkcs7 == NULL) {
        wc_FreeRng(rng);
        return MEMORY_E;
    }
    ret = wc_PKCS7_InitWithCert(*pkcs7, (byte*)tsa_cert_der_2048,
            sizeof_tsa_cert_der_2048);
    if (ret != 0) {
        wc_PKCS7_Free(*pkcs7);
        *pkcs7 = NULL;
        wc_FreeRng(rng);
        return ret;
    }
    (*pkcs7)->rng = rng;
    (*pkcs7)->hashOID = SHA256h;
    (*pkcs7)->encryptOID = RSAk;
    (*pkcs7)->privateKey = (byte*)tsa_key_der_2048;
    (*pkcs7)->privateKeySz = (word32)sizeof_tsa_key_der_2048;
    return 0;
}

static void wb_sign_with_pkcs7_alloc_sweep(void)
{
    TspTstInfo tst;
    wc_PKCS7* pkcs7;
    WC_RNG rng;
    static byte token[3072];
    word32 tokenSz;
    int n;
    const int K = 32; /* generous relative to this function's few alloc sites */

    XMEMSET(&tst, 0, sizeof(tst));
    (void)wc_TspTstInfo_Init(&tst);
    tst.policy = wbPolicy;
    tst.policySz = (word32)sizeof(wbPolicy);
    tst.imprint.hashAlgOID = SHA256h;
    XMEMCPY(tst.imprint.hash, wbHashedMsg, sizeof(wbHashedMsg));
    tst.imprint.hashSz = (word32)sizeof(wbHashedMsg);
    tst.serial = wbSerial;
    tst.serialSz = (word32)sizeof(wbSerial);
    tst.genTime = wbGenTime;
    tst.genTimeSz = (word32)sizeof(wbGenTime) - 1;

    mcdc_fa_install();

    /* Baseline: unarmed success on a fresh signer - also the 1472 all-false
     * row. */
    if (wb_setup_signer(&pkcs7, &rng) != 0) {
        WB_NOTE("signer setup failed; SignWithPkcs7 alloc sweep skipped");
        return;
    }
    tokenSz = (word32)sizeof(token);
    if (wc_TspTstInfo_SignWithPkcs7(&tst, pkcs7, token, &tokenSz) != 0) {
        WB_NOTE("SignWithPkcs7 baseline sign failed");
        wb_fail = 1;
    }
    wc_PKCS7_Free(pkcs7);
    wc_FreeRng(&rng);

    /* Sweep: each n fails one heap allocation site in turn - the tstDer and
     * attribs XMALLOC calls each get their MEMORY_E branch driven with the
     * other allocation still succeeding, plus the WC_ALLOC_VAR_EX signCert
     * site. Over-sweeping past the last site is harmless. A fresh signer
     * each iteration - see wb_setup_signer()'s comment on object reuse. */
    for (n = 1; n <= K; n++) {
        if (wb_setup_signer(&pkcs7, &rng) != 0) {
            continue;
        }
        tokenSz = (word32)sizeof(token);
        mcdc_fa_arm(n);
        (void)wc_TspTstInfo_SignWithPkcs7(&tst, pkcs7, token, &tokenSz);
        mcdc_fa_disarm();
        wc_PKCS7_Free(pkcs7);
        wc_FreeRng(&rng);
    }

    mcdc_fa_disarm();
    mcdc_fa_restore();
    WB_NOTE("wc_TspTstInfo_SignWithPkcs7 allocation-failure sweep done");
}
#else
static void wb_sign_with_pkcs7_alloc_sweep(void) { WB_NOTE("HAVE_PKCS7/WOLFSSL_TSP_RESPONDER/RSA/SHA256 unavailable; SignWithPkcs7 alloc sweep skipped"); }
#endif

/* ------------------------------------------------------------------------- *
 * tsp.c:1683/1697 - Tsp_CheckTsaName() (static) directoryName-compare rows
 * and the rfc822Name/uri name-form rows. Minimal local DER TLV builder -
 * this is a generic ASN.1 utility, not a copy of test_tsp_whitebox.c's
 * Tsp_CheckTsaName test data.
 * ------------------------------------------------------------------------- */
#ifdef WOLFSSL_TSP_VERIFIER
static word32 wbDerLen(byte* buf, word32 n)
{
    if (n < 0x80) {
        buf[0] = (byte)n;
        return 1;
    }
    buf[0] = 0x81;
    buf[1] = (byte)n;
    return 2;
}

static word32 wbBuildTlv(byte* out, byte tag, const byte* content,
        word32 contentLen)
{
    word32 idx = 0;
    byte lenBuf[4];
    word32 lenLen = wbDerLen(lenBuf, contentLen);

    out[idx++] = tag;
    XMEMCPY(out + idx, lenBuf, lenLen);
    idx += lenLen;
    XMEMCPY(out + idx, content, contentLen);
    idx += contentLen;
    return idx;
}

static void wb_check_tsa_name_extra(void)
{
    DecodedCert dCert;
    byte tsa[64];
    byte nameContent[4] = { 0x11, 0x22, 0x33, 0x44 };
    byte name[8];
    word32 nameN;
    word32 n;
    int ret;

    XMEMSET(&dCert, 0, sizeof(dCert));

    /* directoryName [4]{ SEQUENCE{ nameContent } }. */
    nameN = wbBuildTlv(name, ASN_SEQUENCE | ASN_CONSTRUCTED, nameContent,
            sizeof(nameContent));
    n = wbBuildTlv(tsa, (byte)(ASN_CONTEXT_SPECIFIC | ASN_CONSTRUCTED |
            ASN_DIR_TYPE), name, nameN);

    /* 1683 idx0 true: subjectRaw NULL. */
    dCert.subjectRaw = NULL;
    dCert.subjectRawLen = 0;
    ret = Tsp_CheckTsaName(&dCert, tsa, n);
    if (ret != WC_NO_ERR_TRACE(TSP_VERIFY_E)) {
        WB_NOTE("Tsp_CheckTsaName subjectRaw==NULL case misbehaved");
        wb_fail = 1;
    }

    /* 1683 idx2 true, idx0 false: subjectRaw set, same length, differing
     * content. */
    {
        byte subj[4] = { 0x11, 0x22, 0x33, 0x45 };
        dCert.subjectRaw = subj;
        dCert.subjectRawLen = (int)sizeof(nameContent);
        ret = Tsp_CheckTsaName(&dCert, tsa, n);
        if (ret != WC_NO_ERR_TRACE(TSP_VERIFY_E)) {
            WB_NOTE("Tsp_CheckTsaName content-mismatch case misbehaved");
            wb_fail = 1;
        }
    }

    /* 1683 all-false baseline: subjectRaw matches exactly - closes idx0/idx2
     * FALSE rows. */
    dCert.subjectRaw = nameContent;
    dCert.subjectRawLen = (int)sizeof(nameContent);
    ret = Tsp_CheckTsaName(&dCert, tsa, n);
    if (ret != 0) {
        WB_NOTE("Tsp_CheckTsaName match baseline misbehaved");
        wb_fail = 1;
    }

    /* 1697 all-false baseline: an unsupported GeneralName tag (context
     * primitive 0x1E, none of directoryName/rfc822Name/dNSName/uri) falls to
     * the final else - closes 1697 idx0/idx2 FALSE rows. */
    {
        byte content[2] = { 'a', 'b' };
        n = wbBuildTlv(tsa, (byte)(ASN_CONTEXT_SPECIFIC | 0x1E), content,
                sizeof(content));
        ret = Tsp_CheckTsaName(&dCert, tsa, n);
        if (ret != WC_NO_ERR_TRACE(TSP_VERIFY_E)) {
            WB_NOTE("Tsp_CheckTsaName unsupported-form baseline misbehaved");
            wb_fail = 1;
        }
    }

    /* 1697 idx0 true: rfc822Name, no matching altName. */
    {
        byte content[2] = { 'a', 'b' };
        n = wbBuildTlv(tsa, (byte)(ASN_CONTEXT_SPECIFIC | ASN_RFC822_TYPE),
                content, sizeof(content));
        dCert.altNames = NULL;
        ret = Tsp_CheckTsaName(&dCert, tsa, n);
        if (ret != WC_NO_ERR_TRACE(TSP_VERIFY_E)) {
            WB_NOTE("Tsp_CheckTsaName rfc822Name case misbehaved");
            wb_fail = 1;
        }
    }

    /* 1697 idx2 true: uniformResourceIdentifier, with a matching altName
     * (also shows the loop's match path). */
    {
        DNS_entry entry;
        byte content[3] = { 'x', 'y', 'z' };
        n = wbBuildTlv(tsa, (byte)(ASN_CONTEXT_SPECIFIC | ASN_URI_TYPE),
                content, sizeof(content));
        entry.next = NULL;
        entry.type = ASN_URI_TYPE;
        entry.len = 3;
        entry.name = "xyz";
        dCert.altNames = &entry;
        ret = Tsp_CheckTsaName(&dCert, tsa, n);
        if (ret != 0) {
            WB_NOTE("Tsp_CheckTsaName uri case misbehaved");
            wb_fail = 1;
        }
    }

    WB_NOTE("Tsp_CheckTsaName directoryName/name-form MC/DC pairs exercised");
}
#else
static void wb_check_tsa_name_extra(void) { WB_NOTE("WOLFSSL_TSP_VERIFIER off; Tsp_CheckTsaName extra skipped"); }
#endif

/* ------------------------------------------------------------------------- *
 * tsp.c:1763/1773 - Tsp_CheckSignerCert() (static) extended-key-usage and
 * key-usage guards, using hand-built certificates (generated once with
 * openssl req -x509; see each array's comment). ParseCertRelative() runs
 * with NO_VERIFY here, so an invalidated signature (wbKuZeroCert, patched
 * after signing) does not matter - only the extension parse is under test.
 * ------------------------------------------------------------------------- */
#ifdef WOLFSSL_TSP_VERIFIER

/* Self-signed leaf, CN=wb-noeku: basicConstraints=critical,CA:FALSE only -
 * no extendedKeyUsage extension, no keyUsage extension. Drives 1763 idx0
 * true (!extExtKeyUsageSet). */
static const byte wbNoEkuCert[] = {
    0x30, 0x82, 0x03, 0x04, 0x30, 0x82, 0x01, 0xec, 0xa0, 0x03, 0x02, 0x01,
    0x02, 0x02, 0x14, 0x42, 0xe1, 0xb6, 0x98, 0x02, 0xc5, 0x1a, 0x02, 0x48,
    0xd2, 0x47, 0xb7, 0xff, 0x97, 0x58, 0x7d, 0x3a, 0x41, 0xc3, 0x28, 0x30,
    0x0d, 0x06, 0x09, 0x2a, 0x86, 0x48, 0x86, 0xf7, 0x0d, 0x01, 0x01, 0x0b,
    0x05, 0x00, 0x30, 0x13, 0x31, 0x11, 0x30, 0x0f, 0x06, 0x03, 0x55, 0x04,
    0x03, 0x0c, 0x08, 0x77, 0x62, 0x2d, 0x6e, 0x6f, 0x65, 0x6b, 0x75, 0x30,
    0x1e, 0x17, 0x0d, 0x32, 0x36, 0x30, 0x38, 0x30, 0x35, 0x31, 0x31, 0x31,
    0x36, 0x30, 0x37, 0x5a, 0x17, 0x0d, 0x33, 0x36, 0x30, 0x38, 0x30, 0x32,
    0x31, 0x31, 0x31, 0x36, 0x30, 0x37, 0x5a, 0x30, 0x13, 0x31, 0x11, 0x30,
    0x0f, 0x06, 0x03, 0x55, 0x04, 0x03, 0x0c, 0x08, 0x77, 0x62, 0x2d, 0x6e,
    0x6f, 0x65, 0x6b, 0x75, 0x30, 0x82, 0x01, 0x22, 0x30, 0x0d, 0x06, 0x09,
    0x2a, 0x86, 0x48, 0x86, 0xf7, 0x0d, 0x01, 0x01, 0x01, 0x05, 0x00, 0x03,
    0x82, 0x01, 0x0f, 0x00, 0x30, 0x82, 0x01, 0x0a, 0x02, 0x82, 0x01, 0x01,
    0x00, 0xe1, 0xa8, 0x7a, 0xb9, 0x0d, 0x5c, 0x00, 0x08, 0xec, 0xa1, 0xa5,
    0x6a, 0x87, 0x7b, 0x9d, 0xa0, 0xba, 0xcd, 0xfe, 0x2d, 0xa1, 0xf3, 0x9f,
    0x48, 0x01, 0x6d, 0x33, 0x8f, 0x25, 0x38, 0x8b, 0x0c, 0xd8, 0x14, 0x4b,
    0x84, 0x7c, 0x1f, 0x0a, 0xbd, 0x74, 0x34, 0xd5, 0x38, 0x34, 0x70, 0xba,
    0x8b, 0x9b, 0x6a, 0x1d, 0x1f, 0xa2, 0x1d, 0xcd, 0xf3, 0x4f, 0x67, 0x7e,
    0xe1, 0x0a, 0x83, 0xde, 0xd4, 0xc0, 0x7e, 0xc0, 0x29, 0x8c, 0x9f, 0x67,
    0xdb, 0x22, 0x30, 0x86, 0xcc, 0x6e, 0x3b, 0xac, 0xde, 0x83, 0x0e, 0xac,
    0xb7, 0x61, 0x41, 0x77, 0xd4, 0xa3, 0x3f, 0x02, 0x46, 0x03, 0xe4, 0x94,
    0x26, 0x83, 0x60, 0x29, 0x5b, 0x99, 0x48, 0x16, 0xef, 0x82, 0x02, 0xd3,
    0x30, 0xe6, 0x1d, 0x2a, 0x48, 0xa3, 0xf9, 0x6a, 0xc6, 0x6b, 0xfc, 0x9d,
    0x78, 0xe5, 0xe0, 0x04, 0x26, 0xcf, 0x3a, 0x26, 0x53, 0x18, 0x91, 0x57,
    0x72, 0x36, 0x33, 0x9f, 0xf1, 0x07, 0xef, 0xea, 0xa4, 0x81, 0x36, 0xfb,
    0xea, 0x52, 0x90, 0x00, 0xcc, 0xce, 0x57, 0x92, 0x3f, 0x19, 0xe9, 0xdb,
    0x41, 0xc4, 0x56, 0x74, 0x62, 0x34, 0xa2, 0x5c, 0x5d, 0x45, 0x27, 0xe1,
    0x14, 0x63, 0xcd, 0x9f, 0x63, 0xfd, 0x15, 0x2c, 0x58, 0xa2, 0xd5, 0xd8,
    0x8b, 0xd8, 0x4d, 0x45, 0x60, 0xa3, 0x6d, 0xf6, 0xec, 0x8d, 0x17, 0x81,
    0x5a, 0x22, 0xa3, 0x1f, 0xfc, 0x92, 0x10, 0x0a, 0xa3, 0x77, 0xe9, 0xd2,
    0x47, 0x90, 0x50, 0xe9, 0x82, 0x1d, 0xff, 0xc3, 0xe4, 0xf7, 0xaf, 0xb7,
    0xa5, 0x39, 0xfb, 0x09, 0x34, 0x4d, 0x74, 0x0d, 0x7d, 0xa0, 0x93, 0xa9,
    0x53, 0xfd, 0x49, 0xa9, 0xdf, 0x8c, 0x6f, 0x8d, 0xd8, 0x4d, 0x40, 0x80,
    0xbf, 0x66, 0x3e, 0xe9, 0xf8, 0xf3, 0x66, 0x6a, 0x4b, 0xa5, 0x7b, 0x68,
    0xb0, 0x05, 0x0e, 0x33, 0xeb, 0x02, 0x03, 0x01, 0x00, 0x01, 0xa3, 0x50,
    0x30, 0x4e, 0x30, 0x1d, 0x06, 0x03, 0x55, 0x1d, 0x0e, 0x04, 0x16, 0x04,
    0x14, 0xcd, 0x99, 0xec, 0x51, 0x47, 0x5e, 0xce, 0x2d, 0x76, 0x6a, 0x0a,
    0x46, 0x3c, 0x70, 0xdc, 0x92, 0x3c, 0x74, 0xa7, 0x12, 0x30, 0x1f, 0x06,
    0x03, 0x55, 0x1d, 0x23, 0x04, 0x18, 0x30, 0x16, 0x80, 0x14, 0xcd, 0x99,
    0xec, 0x51, 0x47, 0x5e, 0xce, 0x2d, 0x76, 0x6a, 0x0a, 0x46, 0x3c, 0x70,
    0xdc, 0x92, 0x3c, 0x74, 0xa7, 0x12, 0x30, 0x0c, 0x06, 0x03, 0x55, 0x1d,
    0x13, 0x01, 0x01, 0xff, 0x04, 0x02, 0x30, 0x00, 0x30, 0x0d, 0x06, 0x09,
    0x2a, 0x86, 0x48, 0x86, 0xf7, 0x0d, 0x01, 0x01, 0x0b, 0x05, 0x00, 0x03,
    0x82, 0x01, 0x01, 0x00, 0xa8, 0x89, 0x26, 0x41, 0xe0, 0x06, 0xf6, 0xd6,
    0xce, 0x76, 0x5a, 0x48, 0x63, 0xbb, 0x67, 0xab, 0x03, 0x9a, 0xcc, 0xe1,
    0x3d, 0x2b, 0x49, 0x48, 0xe2, 0x5a, 0xd3, 0x18, 0xdd, 0x5e, 0xc1, 0xf1,
    0x4b, 0x06, 0x56, 0x26, 0x58, 0x0f, 0xeb, 0xcf, 0xe2, 0x34, 0xdd, 0x68,
    0x2d, 0xef, 0xbb, 0x76, 0x90, 0x99, 0x33, 0x1e, 0x85, 0xa0, 0x26, 0x47,
    0xc3, 0x07, 0x9a, 0xcf, 0x22, 0x86, 0x82, 0x6e, 0xf1, 0x40, 0xa6, 0x64,
    0xfc, 0xf1, 0x11, 0x2a, 0x4a, 0x04, 0xb1, 0x4e, 0xd4, 0x3e, 0x74, 0x08,
    0xa4, 0x85, 0x8a, 0xa5, 0x72, 0x54, 0x20, 0x36, 0x91, 0x4f, 0xbd, 0x35,
    0x08, 0x1b, 0x43, 0x9e, 0x55, 0x24, 0x8f, 0xa1, 0x10, 0x0e, 0x30, 0x7b,
    0xb8, 0x3e, 0x90, 0xf9, 0x56, 0xc2, 0x86, 0x1d, 0xe7, 0x55, 0x7a, 0x6b,
    0x24, 0xc0, 0xc4, 0xbe, 0xe6, 0x5f, 0x6a, 0xe2, 0xa7, 0x9c, 0xfe, 0x5e,
    0x14, 0xd5, 0x7b, 0xbe, 0x11, 0x1f, 0x22, 0x96, 0x7d, 0xe8, 0x07, 0xad,
    0xb5, 0x1c, 0xb6, 0x66, 0x90, 0xf5, 0x74, 0x39, 0xfa, 0xad, 0xa6, 0x07,
    0x1b, 0x34, 0x56, 0x29, 0xe3, 0xd6, 0x42, 0xcd, 0x79, 0x76, 0x3e, 0xec,
    0x0f, 0x13, 0xf9, 0x7a, 0x92, 0x7e, 0xc0, 0xc6, 0x0b, 0x46, 0xda, 0x31,
    0x35, 0x7a, 0x24, 0x99, 0xb3, 0xb5, 0x8f, 0x5d, 0xe1, 0xb5, 0x30, 0x0b,
    0xd8, 0x52, 0xcb, 0x91, 0x6c, 0xef, 0xd2, 0x18, 0xd2, 0x48, 0x51, 0x49,
    0x77, 0x96, 0x9f, 0x19, 0x5b, 0x7e, 0xcb, 0x3e, 0x4a, 0xc6, 0x04, 0x98,
    0xe5, 0x70, 0xfa, 0xd8, 0xc3, 0xd8, 0xdb, 0x91, 0xe5, 0xa7, 0x06, 0xcd,
    0xe3, 0x1a, 0x20, 0xa9, 0x32, 0x4e, 0xbb, 0x7c, 0x62, 0x4b, 0x90, 0x2d,
    0x34, 0xd5, 0xe1, 0x02, 0x55, 0x4e, 0xae, 0x0c, 0xdc, 0xbe, 0x88, 0xef,
    0x81, 0xa5, 0x85, 0xce, 0xd0, 0x1d, 0x1c, 0x63
};

/* Self-signed leaf, CN=wb-ekunoncrit: extendedKeyUsage=timeStamping, NOT
 * marked critical (openssl default when "critical" is omitted). Drives 1763
 * idx3 true (EKU present, correct OID, count 1, !extExtKeyUsageCrit). */
static const byte wbEkuNonCritCert[] = {
    0x30, 0x82, 0x03, 0x23, 0x30, 0x82, 0x02, 0x0b, 0xa0, 0x03, 0x02, 0x01,
    0x02, 0x02, 0x14, 0x25, 0xff, 0x3b, 0xd8, 0xc7, 0x77, 0xa8, 0x0a, 0x65,
    0x4f, 0x99, 0xcd, 0x22, 0x48, 0xea, 0xe1, 0x9e, 0xaa, 0x49, 0x7b, 0x30,
    0x0d, 0x06, 0x09, 0x2a, 0x86, 0x48, 0x86, 0xf7, 0x0d, 0x01, 0x01, 0x0b,
    0x05, 0x00, 0x30, 0x18, 0x31, 0x16, 0x30, 0x14, 0x06, 0x03, 0x55, 0x04,
    0x03, 0x0c, 0x0d, 0x77, 0x62, 0x2d, 0x65, 0x6b, 0x75, 0x6e, 0x6f, 0x6e,
    0x63, 0x72, 0x69, 0x74, 0x30, 0x1e, 0x17, 0x0d, 0x32, 0x36, 0x30, 0x38,
    0x30, 0x35, 0x31, 0x31, 0x31, 0x36, 0x30, 0x39, 0x5a, 0x17, 0x0d, 0x33,
    0x36, 0x30, 0x38, 0x30, 0x32, 0x31, 0x31, 0x31, 0x36, 0x30, 0x39, 0x5a,
    0x30, 0x18, 0x31, 0x16, 0x30, 0x14, 0x06, 0x03, 0x55, 0x04, 0x03, 0x0c,
    0x0d, 0x77, 0x62, 0x2d, 0x65, 0x6b, 0x75, 0x6e, 0x6f, 0x6e, 0x63, 0x72,
    0x69, 0x74, 0x30, 0x82, 0x01, 0x22, 0x30, 0x0d, 0x06, 0x09, 0x2a, 0x86,
    0x48, 0x86, 0xf7, 0x0d, 0x01, 0x01, 0x01, 0x05, 0x00, 0x03, 0x82, 0x01,
    0x0f, 0x00, 0x30, 0x82, 0x01, 0x0a, 0x02, 0x82, 0x01, 0x01, 0x00, 0xd3,
    0x80, 0xe1, 0x9a, 0x41, 0xd7, 0x3d, 0xfb, 0x40, 0xb1, 0x63, 0x19, 0x17,
    0x98, 0x88, 0xaf, 0x20, 0xfd, 0x79, 0x43, 0x2c, 0x84, 0xb2, 0x85, 0x97,
    0x68, 0x26, 0xb0, 0x4f, 0x5e, 0x00, 0x42, 0xb3, 0x0c, 0xe1, 0x61, 0x7c,
    0x37, 0x0c, 0xc8, 0xe4, 0x81, 0xd7, 0xda, 0x1d, 0x91, 0xd9, 0xc5, 0xe0,
    0xff, 0xd7, 0xa9, 0x83, 0xac, 0x06, 0x12, 0xd8, 0xfa, 0xa1, 0x05, 0xd5,
    0x4f, 0x66, 0x4f, 0x41, 0xbc, 0x22, 0x6e, 0xa9, 0x1e, 0xa1, 0xc8, 0xa1,
    0x43, 0x3d, 0xbc, 0x85, 0x60, 0xd2, 0x8a, 0x43, 0xb6, 0xcb, 0x57, 0x0c,
    0x0a, 0xdd, 0xc8, 0xae, 0xa4, 0x6b, 0x7d, 0xce, 0x0d, 0x44, 0x88, 0xcb,
    0xdd, 0xb9, 0x58, 0x19, 0x5e, 0xc3, 0xf0, 0x5e, 0xc4, 0xdc, 0x0e, 0xd6,
    0x1e, 0x4b, 0xd9, 0x15, 0x12, 0x7c, 0x2a, 0xc5, 0x24, 0x5b, 0x41, 0x99,
    0x3c, 0xfa, 0x16, 0x12, 0x52, 0x3e, 0xfe, 0x6d, 0xc8, 0xfe, 0x5d, 0xb7,
    0xe0, 0xf2, 0xaa, 0x20, 0x50, 0x8b, 0xc2, 0x6e, 0x59, 0x24, 0xcb, 0xbb,
    0x36, 0xaa, 0xeb, 0x01, 0x36, 0x72, 0x5f, 0x32, 0xd9, 0xfc, 0x53, 0x50,
    0xd4, 0xe9, 0x0c, 0x21, 0x07, 0xc3, 0xdf, 0x11, 0x3c, 0x8e, 0xa8, 0xc9,
    0x66, 0x78, 0x71, 0xc0, 0xc7, 0x6c, 0x84, 0xa6, 0x0d, 0x02, 0xe6, 0x19,
    0xb2, 0xf1, 0x9b, 0x7d, 0x8a, 0x44, 0x28, 0x6e, 0xc7, 0x73, 0x93, 0x20,
    0xb1, 0xbf, 0xb2, 0x93, 0x3f, 0xd1, 0x11, 0x24, 0x6b, 0x1c, 0x4d, 0x65,
    0x49, 0x89, 0x4b, 0xa0, 0xfb, 0x92, 0x67, 0xf3, 0xc8, 0xda, 0xfa, 0x7a,
    0x60, 0xa7, 0x3f, 0x75, 0x7b, 0xc2, 0xb7, 0x99, 0xda, 0xc4, 0xba, 0xc2,
    0xf1, 0x26, 0xd4, 0x1d, 0xbb, 0xc4, 0x4a, 0x35, 0x4d, 0x30, 0x85, 0x94,
    0xbe, 0x24, 0x7a, 0xf2, 0xc6, 0x1c, 0x7c, 0x78, 0x33, 0x8b, 0xe4, 0xef,
    0x62, 0xd4, 0xf9, 0x02, 0x03, 0x01, 0x00, 0x01, 0xa3, 0x65, 0x30, 0x63,
    0x30, 0x1d, 0x06, 0x03, 0x55, 0x1d, 0x0e, 0x04, 0x16, 0x04, 0x14, 0xff,
    0xaa, 0x67, 0x12, 0x3a, 0x00, 0x25, 0x0f, 0x91, 0x07, 0x39, 0xe4, 0x0f,
    0xe9, 0xab, 0xe9, 0x64, 0x8c, 0xa8, 0xd9, 0x30, 0x1f, 0x06, 0x03, 0x55,
    0x1d, 0x23, 0x04, 0x18, 0x30, 0x16, 0x80, 0x14, 0xff, 0xaa, 0x67, 0x12,
    0x3a, 0x00, 0x25, 0x0f, 0x91, 0x07, 0x39, 0xe4, 0x0f, 0xe9, 0xab, 0xe9,
    0x64, 0x8c, 0xa8, 0xd9, 0x30, 0x0c, 0x06, 0x03, 0x55, 0x1d, 0x13, 0x01,
    0x01, 0xff, 0x04, 0x02, 0x30, 0x00, 0x30, 0x13, 0x06, 0x03, 0x55, 0x1d,
    0x25, 0x04, 0x0c, 0x30, 0x0a, 0x06, 0x08, 0x2b, 0x06, 0x01, 0x05, 0x05,
    0x07, 0x03, 0x08, 0x30, 0x0d, 0x06, 0x09, 0x2a, 0x86, 0x48, 0x86, 0xf7,
    0x0d, 0x01, 0x01, 0x0b, 0x05, 0x00, 0x03, 0x82, 0x01, 0x01, 0x00, 0xaa,
    0x5c, 0x99, 0x00, 0x29, 0x68, 0x23, 0x05, 0xc1, 0xc2, 0x11, 0xe1, 0x61,
    0xb9, 0x28, 0xc0, 0x7a, 0x51, 0x48, 0x6f, 0xb8, 0x99, 0x45, 0xc5, 0x05,
    0x68, 0x51, 0x4a, 0x53, 0x2b, 0x33, 0x0f, 0xa6, 0xdd, 0xca, 0x39, 0xdb,
    0x19, 0x95, 0x4a, 0xc8, 0xe2, 0xcc, 0x82, 0xd5, 0x46, 0x31, 0xf5, 0x3d,
    0x78, 0x0b, 0x8e, 0x9b, 0x03, 0x3d, 0x26, 0xf8, 0xd4, 0x01, 0x68, 0xc4,
    0xbb, 0x2b, 0x91, 0x0e, 0x4d, 0xf2, 0x60, 0xb4, 0x69, 0x6a, 0x82, 0x15,
    0x2f, 0x8f, 0x34, 0x41, 0x61, 0x24, 0xa5, 0xce, 0xb5, 0x5f, 0x65, 0xcc,
    0x51, 0xc6, 0x5a, 0x32, 0x8f, 0x45, 0x84, 0x46, 0xd4, 0x7d, 0x8d, 0x37,
    0x3a, 0x48, 0xb7, 0x64, 0x5f, 0x0e, 0x8d, 0x60, 0x12, 0x4a, 0x0a, 0xa5,
    0x8a, 0xa5, 0x95, 0x20, 0xbc, 0x9f, 0xc3, 0x5d, 0x8a, 0x21, 0xf2, 0x02,
    0x14, 0x4c, 0xb1, 0xa6, 0xbc, 0xf8, 0x97, 0x6c, 0x3d, 0x2e, 0xd2, 0x9e,
    0x56, 0x09, 0x2b, 0x6e, 0xf5, 0xb7, 0x91, 0xa0, 0xb4, 0xa7, 0x09, 0x8f,
    0xf0, 0x45, 0xc2, 0x52, 0xac, 0x64, 0x66, 0xda, 0x2b, 0x11, 0x28, 0xf2,
    0xf9, 0xb2, 0x8b, 0x30, 0x4a, 0x57, 0x25, 0x77, 0x95, 0x72, 0xc0, 0xde,
    0x9b, 0x78, 0xa8, 0x8d, 0xff, 0x2f, 0x09, 0xbd, 0xe7, 0xd7, 0x98, 0xfd,
    0xbb, 0x79, 0x3c, 0x4d, 0xd0, 0x5a, 0xed, 0xf3, 0xbf, 0x1f, 0xe8, 0xa4,
    0x67, 0xbd, 0x59, 0x75, 0x94, 0x99, 0xf9, 0x1f, 0x70, 0x79, 0xa8, 0xba,
    0xc5, 0x85, 0x7d, 0x61, 0xe7, 0x5d, 0x4f, 0x39, 0xa2, 0x31, 0x6e, 0x90,
    0x78, 0x50, 0x96, 0x1f, 0x34, 0xd1, 0xaf, 0x22, 0xf4, 0xaa, 0x5b, 0xd1,
    0xee, 0xd1, 0x10, 0x05, 0xd2, 0x85, 0x1d, 0x17, 0x39, 0x75, 0x68, 0xa5,
    0x51, 0xbb, 0x06, 0x59, 0x84, 0x4a, 0x23, 0x92, 0x6a, 0x81, 0x77, 0x6c,
    0xf8, 0x83, 0x2b
};

/* Self-signed leaf, CN=wb-ekuonly: extendedKeyUsage=critical,timeStamping,
 * no keyUsage extension. All-false baseline for 1763 (correct, critical,
 * single OID) and 1773 idx0 false baseline (!extKeyUsageSet: no KU at all). */
static const byte wbEkuOnlyCert[] = {
    0x30, 0x82, 0x03, 0x20, 0x30, 0x82, 0x02, 0x08, 0xa0, 0x03, 0x02, 0x01,
    0x02, 0x02, 0x14, 0x7a, 0xb1, 0x4e, 0x47, 0xbf, 0xe8, 0x85, 0x0c, 0x84,
    0x5c, 0xeb, 0xcd, 0xf9, 0x81, 0x41, 0x0a, 0x08, 0x87, 0xb6, 0x29, 0x30,
    0x0d, 0x06, 0x09, 0x2a, 0x86, 0x48, 0x86, 0xf7, 0x0d, 0x01, 0x01, 0x0b,
    0x05, 0x00, 0x30, 0x15, 0x31, 0x13, 0x30, 0x11, 0x06, 0x03, 0x55, 0x04,
    0x03, 0x0c, 0x0a, 0x77, 0x62, 0x2d, 0x65, 0x6b, 0x75, 0x6f, 0x6e, 0x6c,
    0x79, 0x30, 0x1e, 0x17, 0x0d, 0x32, 0x36, 0x30, 0x38, 0x30, 0x35, 0x31,
    0x31, 0x31, 0x36, 0x31, 0x30, 0x5a, 0x17, 0x0d, 0x33, 0x36, 0x30, 0x38,
    0x30, 0x32, 0x31, 0x31, 0x31, 0x36, 0x31, 0x30, 0x5a, 0x30, 0x15, 0x31,
    0x13, 0x30, 0x11, 0x06, 0x03, 0x55, 0x04, 0x03, 0x0c, 0x0a, 0x77, 0x62,
    0x2d, 0x65, 0x6b, 0x75, 0x6f, 0x6e, 0x6c, 0x79, 0x30, 0x82, 0x01, 0x22,
    0x30, 0x0d, 0x06, 0x09, 0x2a, 0x86, 0x48, 0x86, 0xf7, 0x0d, 0x01, 0x01,
    0x01, 0x05, 0x00, 0x03, 0x82, 0x01, 0x0f, 0x00, 0x30, 0x82, 0x01, 0x0a,
    0x02, 0x82, 0x01, 0x01, 0x00, 0x9e, 0xb7, 0xdf, 0x6d, 0x8c, 0x23, 0xd0,
    0xbf, 0xa2, 0xf4, 0x3d, 0x62, 0x24, 0x34, 0x58, 0xaa, 0xc7, 0xf0, 0x84,
    0xa8, 0xff, 0xd1, 0x38, 0x7e, 0x50, 0x14, 0x68, 0x4b, 0x45, 0x21, 0x9f,
    0x12, 0x09, 0xf2, 0x95, 0x9d, 0x04, 0x8b, 0x01, 0xd3, 0x73, 0x8e, 0x15,
    0x09, 0xa1, 0x1f, 0xc1, 0x23, 0x59, 0xbe, 0x0e, 0x24, 0xed, 0xe5, 0x3f,
    0x8a, 0x38, 0x10, 0x72, 0x8e, 0x88, 0xf7, 0x9d, 0x06, 0xd2, 0x08, 0x24,
    0x5d, 0xe1, 0x3e, 0x28, 0x52, 0x07, 0xe6, 0xd5, 0x76, 0xe5, 0x39, 0x0a,
    0xa5, 0x94, 0xc6, 0x6c, 0x22, 0x65, 0x27, 0x18, 0xd5, 0x4a, 0x6d, 0x92,
    0x81, 0x83, 0xd9, 0x67, 0x69, 0xe3, 0x66, 0x8d, 0xf2, 0xe9, 0xb0, 0x15,
    0x52, 0xff, 0x60, 0x74, 0x9e, 0x3b, 0x88, 0xfe, 0x93, 0xd1, 0xe9, 0x85,
    0x29, 0x22, 0x28, 0x17, 0xee, 0xaa, 0x2e, 0xa4, 0x95, 0xbb, 0x5a, 0xc6,
    0x1b, 0x39, 0x98, 0x26, 0x89, 0xd3, 0x10, 0x47, 0x89, 0xeb, 0x7f, 0xf7,
    0x70, 0xbe, 0x3c, 0x30, 0xbe, 0x0b, 0x33, 0x2a, 0x08, 0x7e, 0x99, 0x90,
    0x61, 0xc9, 0x3f, 0x21, 0x25, 0x1e, 0xe6, 0x0a, 0xd1, 0x4b, 0xf2, 0x25,
    0xf3, 0xb8, 0xa2, 0x3c, 0xf1, 0xde, 0xaa, 0x91, 0x43, 0xed, 0x84, 0x51,
    0xd8, 0x3d, 0x7e, 0xeb, 0x60, 0x06, 0x40, 0x17, 0x42, 0x43, 0xd4, 0xa2,
    0xee, 0xb9, 0xc3, 0xc0, 0xb2, 0xab, 0x1f, 0xd4, 0x96, 0x3c, 0x3e, 0x1c,
    0x3d, 0x02, 0x92, 0xa2, 0xf1, 0x5d, 0x66, 0x4c, 0x7d, 0x14, 0xa8, 0x79,
    0x7f, 0x17, 0xa4, 0x28, 0x72, 0xfc, 0xcc, 0x50, 0x4e, 0x42, 0xc7, 0x71,
    0xd7, 0x90, 0xbb, 0x5f, 0x00, 0x4a, 0xba, 0xef, 0x4e, 0xca, 0xde, 0x6b,
    0xa7, 0x66, 0x49, 0x22, 0x6c, 0x9e, 0x17, 0xb8, 0x19, 0x29, 0x68, 0xd7,
    0xeb, 0xe4, 0x6e, 0x77, 0x3e, 0x32, 0xf9, 0x9c, 0x75, 0x02, 0x03, 0x01,
    0x00, 0x01, 0xa3, 0x68, 0x30, 0x66, 0x30, 0x1d, 0x06, 0x03, 0x55, 0x1d,
    0x0e, 0x04, 0x16, 0x04, 0x14, 0x30, 0x2c, 0xbd, 0xc7, 0x09, 0xe8, 0x4a,
    0xb4, 0xd0, 0x99, 0x36, 0x51, 0xe4, 0x59, 0x09, 0xf5, 0x5e, 0xec, 0x79,
    0xfb, 0x30, 0x1f, 0x06, 0x03, 0x55, 0x1d, 0x23, 0x04, 0x18, 0x30, 0x16,
    0x80, 0x14, 0x30, 0x2c, 0xbd, 0xc7, 0x09, 0xe8, 0x4a, 0xb4, 0xd0, 0x99,
    0x36, 0x51, 0xe4, 0x59, 0x09, 0xf5, 0x5e, 0xec, 0x79, 0xfb, 0x30, 0x0c,
    0x06, 0x03, 0x55, 0x1d, 0x13, 0x01, 0x01, 0xff, 0x04, 0x02, 0x30, 0x00,
    0x30, 0x16, 0x06, 0x03, 0x55, 0x1d, 0x25, 0x01, 0x01, 0xff, 0x04, 0x0c,
    0x30, 0x0a, 0x06, 0x08, 0x2b, 0x06, 0x01, 0x05, 0x05, 0x07, 0x03, 0x08,
    0x30, 0x0d, 0x06, 0x09, 0x2a, 0x86, 0x48, 0x86, 0xf7, 0x0d, 0x01, 0x01,
    0x0b, 0x05, 0x00, 0x03, 0x82, 0x01, 0x01, 0x00, 0x01, 0x9f, 0xb2, 0x62,
    0x0c, 0xa4, 0x9d, 0x7b, 0x4f, 0x2a, 0x68, 0x69, 0xcc, 0x7f, 0x35, 0x35,
    0xa3, 0xa3, 0xb2, 0x99, 0x42, 0x5f, 0xd3, 0x72, 0xe3, 0xf5, 0xcc, 0x7f,
    0xea, 0x30, 0x87, 0xca, 0xf3, 0x81, 0x9e, 0xb7, 0x3c, 0x6c, 0xae, 0xa0,
    0x0a, 0x48, 0x15, 0xa9, 0x4b, 0xca, 0x93, 0xc5, 0x9c, 0x57, 0x99, 0xa9,
    0x9e, 0x13, 0x35, 0x48, 0xc0, 0xf2, 0xbb, 0x05, 0xe1, 0x25, 0xee, 0xda,
    0xa3, 0x8c, 0xdd, 0x2c, 0x9d, 0x52, 0x65, 0xcf, 0x94, 0xc5, 0x03, 0x83,
    0xd4, 0x11, 0x96, 0x5b, 0x12, 0xd6, 0xc1, 0x34, 0x88, 0xfa, 0x25, 0x0e,
    0x69, 0x5b, 0x17, 0x79, 0xc3, 0xcb, 0xfa, 0x5c, 0xaf, 0xbf, 0x95, 0x0f,
    0x75, 0x4e, 0x9e, 0x3b, 0xcc, 0x67, 0x99, 0xdc, 0x9b, 0x25, 0x54, 0xf6,
    0xe6, 0xc5, 0xf8, 0x48, 0xe4, 0x1c, 0xd6, 0xb5, 0x6d, 0xf3, 0x03, 0x02,
    0xb4, 0x71, 0x37, 0x89, 0xbf, 0x00, 0x7f, 0x31, 0xe5, 0x2f, 0x2d, 0x45,
    0x37, 0x97, 0x9c, 0x6b, 0x20, 0x94, 0xca, 0x2d, 0xfa, 0x89, 0xf9, 0xbb,
    0xbf, 0x5f, 0xe5, 0xf5, 0xe7, 0x79, 0x80, 0x0d, 0xc9, 0x76, 0x9c, 0xd4,
    0xd2, 0x97, 0x6b, 0x07, 0x06, 0xe0, 0xe5, 0x2d, 0xb1, 0x30, 0x41, 0x14,
    0xc8, 0x0c, 0xa8, 0xdb, 0x87, 0xc8, 0x98, 0x33, 0xb2, 0xf3, 0x19, 0xcb,
    0x86, 0xc3, 0xe8, 0xfa, 0x19, 0x51, 0xaa, 0x2c, 0x24, 0x78, 0xda, 0x75,
    0xb3, 0xaf, 0x93, 0x2f, 0x88, 0x17, 0x02, 0x9c, 0xbf, 0x82, 0x47, 0xfd,
    0x20, 0xd9, 0x5a, 0xe4, 0x6e, 0x86, 0xbe, 0x0e, 0x6d, 0x1c, 0xd7, 0x2c,
    0x5c, 0xea, 0x0a, 0x02, 0xb3, 0x50, 0x6b, 0x4e, 0x5a, 0x2b, 0xde, 0x28,
    0x69, 0xc6, 0x14, 0xb5, 0x46, 0xd3, 0x12, 0x11, 0xb4, 0xac, 0xde, 0xeb,
    0xaa, 0xbb, 0xba, 0x1d, 0xdf, 0x1a, 0x23, 0x3c, 0xb1, 0xad, 0x1d, 0xf3
};

/* Self-signed leaf, CN=wb-kuzero: extendedKeyUsage=critical,timeStamping
 * (correct, so 1763 passes) plus keyUsage=critical,keyEncipherment,
 * generated and then binary-patched: the KeyUsage extension's BIT STRING
 * content byte (unused-bits count 5, single content byte at a fixed offset
 * in this exact encoding) is zeroed after signing, turning "keyEncipherment
 * only" into "no bit set at all" while keeping the DER length identical (so
 * no other offset in the certificate shifts). Drives 1773 idx0 true
 * (extKeyUsageSet) with idx1 false (no bit outside {digitalSignature,
 * contentCommitment} is set - there are no bits set at all) and idx2 true
 * (neither digitalSignature nor contentCommitment is set either). The
 * patch invalidates the RSA signature, which does not matter here -
 * Tsp_CheckSignerCert() parses with NO_VERIFY. */
static const byte wbKuZeroCert[] = {
    0x30, 0x82, 0x03, 0x2e, 0x30, 0x82, 0x02, 0x16, 0xa0, 0x03, 0x02, 0x01,
    0x02, 0x02, 0x14, 0x39, 0xa0, 0xc0, 0xb4, 0xea, 0x67, 0xdd, 0xa1, 0x67,
    0xb3, 0x57, 0x36, 0xd1, 0xfd, 0x2e, 0xde, 0xd2, 0x0a, 0x8c, 0xfb, 0x30,
    0x0d, 0x06, 0x09, 0x2a, 0x86, 0x48, 0x86, 0xf7, 0x0d, 0x01, 0x01, 0x0b,
    0x05, 0x00, 0x30, 0x14, 0x31, 0x12, 0x30, 0x10, 0x06, 0x03, 0x55, 0x04,
    0x03, 0x0c, 0x09, 0x77, 0x62, 0x2d, 0x6b, 0x75, 0x7a, 0x65, 0x72, 0x6f,
    0x30, 0x1e, 0x17, 0x0d, 0x32, 0x36, 0x30, 0x38, 0x30, 0x35, 0x31, 0x31,
    0x31, 0x36, 0x31, 0x35, 0x5a, 0x17, 0x0d, 0x33, 0x36, 0x30, 0x38, 0x30,
    0x32, 0x31, 0x31, 0x31, 0x36, 0x31, 0x35, 0x5a, 0x30, 0x14, 0x31, 0x12,
    0x30, 0x10, 0x06, 0x03, 0x55, 0x04, 0x03, 0x0c, 0x09, 0x77, 0x62, 0x2d,
    0x6b, 0x75, 0x7a, 0x65, 0x72, 0x6f, 0x30, 0x82, 0x01, 0x22, 0x30, 0x0d,
    0x06, 0x09, 0x2a, 0x86, 0x48, 0x86, 0xf7, 0x0d, 0x01, 0x01, 0x01, 0x05,
    0x00, 0x03, 0x82, 0x01, 0x0f, 0x00, 0x30, 0x82, 0x01, 0x0a, 0x02, 0x82,
    0x01, 0x01, 0x00, 0xd0, 0x5c, 0x4f, 0x5f, 0x25, 0xb6, 0x59, 0xca, 0x1a,
    0xd1, 0x23, 0xf4, 0x4d, 0xda, 0x04, 0x11, 0xc9, 0xec, 0x1e, 0x19, 0x7d,
    0xc8, 0xe4, 0x14, 0xf0, 0x96, 0xa5, 0x30, 0x1a, 0xe5, 0x96, 0xc8, 0xa0,
    0x54, 0x01, 0x0a, 0xb1, 0x7b, 0x02, 0x4a, 0x42, 0xa6, 0x78, 0xf1, 0xa4,
    0x94, 0x8a, 0xe7, 0x5e, 0x4e, 0xfc, 0x70, 0xab, 0x5c, 0xfd, 0x26, 0xda,
    0x1a, 0xf7, 0xc5, 0xc2, 0x72, 0x45, 0x86, 0xf7, 0xeb, 0x76, 0x9c, 0xaf,
    0xd2, 0x47, 0x14, 0x06, 0x6d, 0x69, 0x3f, 0xed, 0x44, 0x67, 0xe4, 0x8d,
    0x32, 0x37, 0x0f, 0x92, 0x21, 0xcd, 0xbe, 0xce, 0x29, 0x23, 0x8a, 0x08,
    0xb4, 0x5a, 0xf0, 0x9c, 0x2e, 0x5a, 0xf1, 0xb7, 0x6b, 0xed, 0x55, 0x33,
    0xc7, 0x9f, 0xa9, 0xbd, 0xd9, 0x4f, 0xf5, 0x1f, 0xea, 0x3d, 0x08, 0xee,
    0xc8, 0xda, 0xa3, 0x52, 0xa0, 0x1f, 0x22, 0xc8, 0xfd, 0x2f, 0x73, 0x89,
    0x1b, 0xec, 0xac, 0x42, 0x57, 0xad, 0x9a, 0x43, 0xb6, 0xf8, 0x03, 0xb6,
    0x2a, 0x13, 0x95, 0xb0, 0x71, 0xbf, 0x39, 0x3f, 0xc5, 0x7e, 0xfe, 0xe7,
    0x19, 0xc1, 0xdf, 0x1c, 0x90, 0x3b, 0x78, 0xbd, 0xf2, 0xc1, 0x22, 0x0e,
    0x39, 0x7a, 0xd6, 0xf1, 0xcf, 0x13, 0x26, 0x40, 0xcd, 0xc9, 0xb0, 0x5b,
    0x0b, 0x2d, 0x2a, 0x93, 0x42, 0x37, 0x53, 0xb3, 0xb1, 0x19, 0xf7, 0xb1,
    0x18, 0xf8, 0x18, 0x91, 0xb7, 0xaa, 0xb9, 0x97, 0xf4, 0xdb, 0x9f, 0x2a,
    0x54, 0xa4, 0x12, 0x94, 0x7e, 0x80, 0xd8, 0xe4, 0x18, 0x70, 0x87, 0x6a,
    0x4c, 0x4c, 0xc9, 0xae, 0x53, 0x83, 0xf9, 0xff, 0x1d, 0x6c, 0x0d, 0x55,
    0x7f, 0x32, 0x87, 0x41, 0xf0, 0xa0, 0x03, 0x45, 0x1e, 0x94, 0x97, 0x38,
    0x22, 0xab, 0x77, 0xdf, 0xb1, 0xec, 0x56, 0x1e, 0x1c, 0xb9, 0x14, 0x78,
    0xa4, 0x10, 0x34, 0xcf, 0x10, 0x7f, 0x2d, 0x02, 0x03, 0x01, 0x00, 0x01,
    0xa3, 0x78, 0x30, 0x76, 0x30, 0x1d, 0x06, 0x03, 0x55, 0x1d, 0x0e, 0x04,
    0x16, 0x04, 0x14, 0x76, 0xb4, 0xff, 0x4a, 0x77, 0xf1, 0xd2, 0x72, 0x4e,
    0x57, 0xe6, 0xa6, 0x45, 0x6e, 0xd8, 0x20, 0x9c, 0xf2, 0xd8, 0xef, 0x30,
    0x1f, 0x06, 0x03, 0x55, 0x1d, 0x23, 0x04, 0x18, 0x30, 0x16, 0x80, 0x14,
    0x76, 0xb4, 0xff, 0x4a, 0x77, 0xf1, 0xd2, 0x72, 0x4e, 0x57, 0xe6, 0xa6,
    0x45, 0x6e, 0xd8, 0x20, 0x9c, 0xf2, 0xd8, 0xef, 0x30, 0x0c, 0x06, 0x03,
    0x55, 0x1d, 0x13, 0x01, 0x01, 0xff, 0x04, 0x02, 0x30, 0x00, 0x30, 0x16,
    0x06, 0x03, 0x55, 0x1d, 0x25, 0x01, 0x01, 0xff, 0x04, 0x0c, 0x30, 0x0a,
    0x06, 0x08, 0x2b, 0x06, 0x01, 0x05, 0x05, 0x07, 0x03, 0x08, 0x30, 0x0e,
    0x06, 0x03, 0x55, 0x1d, 0x0f, 0x01, 0x01, 0xff, 0x04, 0x04, 0x03, 0x02,
    0x05, 0x00, 0x30, 0x0d, 0x06, 0x09, 0x2a, 0x86, 0x48, 0x86, 0xf7, 0x0d,
    0x01, 0x01, 0x0b, 0x05, 0x00, 0x03, 0x82, 0x01, 0x01, 0x00, 0x50, 0x98,
    0xe5, 0x27, 0xb4, 0x47, 0x47, 0x0f, 0x44, 0xb4, 0xfa, 0xbe, 0x99, 0x88,
    0xc8, 0xcf, 0x0c, 0x03, 0x1a, 0x63, 0xa3, 0x80, 0x90, 0xf8, 0x41, 0x04,
    0x54, 0x65, 0xf5, 0x0c, 0x4c, 0x23, 0xd6, 0xcb, 0x86, 0xff, 0xcd, 0x3b,
    0xc5, 0xd1, 0xd2, 0x7b, 0x14, 0xc1, 0x95, 0x5e, 0x95, 0x5b, 0x07, 0x82,
    0x8e, 0x08, 0xfb, 0xe7, 0x74, 0xcc, 0xc6, 0x7c, 0x94, 0xf1, 0xdd, 0xf2,
    0xd1, 0x0b, 0xe0, 0x04, 0x95, 0x08, 0x28, 0xf2, 0x29, 0x89, 0x71, 0xed,
    0x84, 0xa3, 0xc0, 0xf9, 0x23, 0xab, 0xd9, 0x46, 0xb8, 0xaa, 0xd9, 0xb9,
    0xf1, 0x85, 0x12, 0x6e, 0xf7, 0x39, 0x64, 0xd5, 0xf3, 0xb5, 0x57, 0x88,
    0x64, 0xe4, 0xb6, 0x84, 0xa0, 0x05, 0xe1, 0x1b, 0x64, 0xe8, 0x3c, 0x02,
    0xcf, 0xee, 0x40, 0x21, 0xb6, 0xb0, 0x93, 0x9a, 0x12, 0x10, 0x47, 0xee,
    0x42, 0x0e, 0x09, 0xe2, 0xc4, 0x9b, 0x1d, 0xb6, 0x4d, 0x7f, 0x1c, 0x82,
    0xff, 0x45, 0xae, 0x9d, 0xf3, 0x69, 0x9e, 0x0d, 0x83, 0x21, 0xa4, 0xa8,
    0x63, 0xd4, 0x3d, 0x2e, 0x5b, 0x69, 0x61, 0x1f, 0x3b, 0xc3, 0xee, 0xc4,
    0x37, 0x18, 0xfb, 0x87, 0x54, 0x1a, 0xdf, 0xd9, 0x82, 0x6e, 0x58, 0x70,
    0x3c, 0x2d, 0x46, 0x27, 0x8f, 0x1c, 0x69, 0x1d, 0xa4, 0xdb, 0x6f, 0x72,
    0x92, 0x88, 0xa3, 0x6f, 0x96, 0xbc, 0xdb, 0x2a, 0x0f, 0x3c, 0x81, 0x2e,
    0xf3, 0xbf, 0x42, 0xcc, 0xed, 0x86, 0x6c, 0xd4, 0x53, 0x8a, 0xe4, 0x4f,
    0x4c, 0x4c, 0xb2, 0x72, 0xf5, 0x81, 0x28, 0xf7, 0xab, 0xd0, 0xf2, 0xd4,
    0x32, 0x6a, 0x2d, 0x61, 0x3d, 0xdd, 0x74, 0x34, 0xd7, 0x1e, 0xee, 0x2c,
    0x94, 0x91, 0xcf, 0x12, 0x34, 0xf7, 0x59, 0xda, 0xf2, 0x27, 0x79, 0x65,
    0x46, 0x19, 0xfb, 0x0d, 0xc0, 0xad, 0x25, 0x50, 0x30, 0xb6, 0x96, 0x6c,
    0x8f, 0x97
};

static void wb_check_signer_cert_extra(void)
{
    int ret;

    /* 1763 idx0 true: no EKU extension at all. */
    ret = Tsp_CheckSignerCert(wbNoEkuCert, sizeof(wbNoEkuCert), NULL, 0, NULL);
    if (ret != WC_NO_ERR_TRACE(EXTKEYUSAGE_E)) {
        WB_NOTE("Tsp_CheckSignerCert no-EKU case misbehaved");
        wb_fail = 1;
    }

    /* 1763 idx3 true: EKU present, correct OID, one OID, not critical. */
    ret = Tsp_CheckSignerCert(wbEkuNonCritCert, sizeof(wbEkuNonCritCert), NULL,
            0, NULL);
    if (ret != WC_NO_ERR_TRACE(EXTKEYUSAGE_E)) {
        WB_NOTE("Tsp_CheckSignerCert non-critical-EKU case misbehaved");
        wb_fail = 1;
    }

    /* 1763 all-false baseline / 1773 idx0 false baseline. */
    ret = Tsp_CheckSignerCert(wbEkuOnlyCert, sizeof(wbEkuOnlyCert), NULL, 0,
            NULL);
    if (ret != 0) {
        WB_NOTE("Tsp_CheckSignerCert EKU-only baseline misbehaved");
        wb_fail = 1;
    }

    /* 1773 idx0 true, idx1 false, idx2 true: KeyUsage present, zero bits. */
    ret = Tsp_CheckSignerCert(wbKuZeroCert, sizeof(wbKuZeroCert), NULL, 0,
            NULL);
    if (ret != WC_NO_ERR_TRACE(KEYUSAGE_E)) {
        WB_NOTE("Tsp_CheckSignerCert zero-KU case misbehaved");
        wb_fail = 1;
    }

    WB_NOTE("Tsp_CheckSignerCert EKU/KU MC/DC pairs exercised (1763, 1773)");
}
#else
static void wb_check_signer_cert_extra(void) { WB_NOTE("WOLFSSL_TSP_VERIFIER off; Tsp_CheckSignerCert extra skipped"); }
#endif

/* ------------------------------------------------------------------------- *
 * tsp.c:2162 - TspResponse_Verify() (static) cm != NULL decision, reached
 * only once a real signed CMS token verifies (ret == 0 at that point).
 * Bonus: the same successful verify closes the 2179/2188 tstInfo!=NULL /
 * contentSz>0 true rows, and a tstInfo==NULL call closes their false rows.
 * ------------------------------------------------------------------------- */
#if defined(WOLFSSL_TSP_RESPONDER) && defined(WOLFSSL_TSP_VERIFIER) && \
    defined(HAVE_PKCS7) && !defined(NO_RSA) && !defined(NO_SHA256)

/* Build a real signed TimeStampToken - real RSA signature over real
 * SignedAttributes, using tsa_cert_der_2048/tsa_key_der_2048, the same way
 * tests/api/test_tsp.c's test_tsp_make_token() does. Returns 0 and fills
 * *tokenSz on success. */
static int wb_make_token(byte* token, word32* tokenSz)
{
    TspTstInfo tst;
    wc_PKCS7* pkcs7;
    WC_RNG rng;
    int ret;

    XMEMSET(&tst, 0, sizeof(tst));
    (void)wc_TspTstInfo_Init(&tst);
    tst.policy = wbPolicy;
    tst.policySz = (word32)sizeof(wbPolicy);
    tst.imprint.hashAlgOID = SHA256h;
    XMEMCPY(tst.imprint.hash, wbHashedMsg, sizeof(wbHashedMsg));
    tst.imprint.hashSz = (word32)sizeof(wbHashedMsg);
    tst.serial = wbSerial;
    tst.serialSz = (word32)sizeof(wbSerial);
    tst.genTime = wbGenTime;
    tst.genTimeSz = (word32)sizeof(wbGenTime) - 1;

    ret = wc_InitRng(&rng);
    if (ret != 0) {
        return ret;
    }

    pkcs7 = wc_PKCS7_New(NULL, INVALID_DEVID);
    if (pkcs7 == NULL) {
        wc_FreeRng(&rng);
        return MEMORY_E;
    }
    ret = wc_PKCS7_InitWithCert(pkcs7, (byte*)tsa_cert_der_2048,
            sizeof_tsa_cert_der_2048);
    if (ret == 0) {
        pkcs7->rng = &rng;
        pkcs7->hashOID = SHA256h;
        pkcs7->encryptOID = RSAk;
        pkcs7->privateKey = (byte*)tsa_key_der_2048;
        pkcs7->privateKeySz = (word32)sizeof_tsa_key_der_2048;
        ret = wc_TspTstInfo_SignWithPkcs7(&tst, pkcs7, token, tokenSz);
    }
    wc_PKCS7_Free(pkcs7);
    wc_FreeRng(&rng);
    return ret;
}

static void wb_response_verify_cm(void)
{
    static byte token[3072];
    word32 tokenSz = (word32)sizeof(token);
    TspResponse resp;
    TspTstInfo tstOut;
    int ret;
    WOLFSSL_CERT_MANAGER* cm;

    if (wb_make_token(token, &tokenSz) != 0) {
        WB_NOTE("wb_make_token failed; TspResponse_Verify cm rows skipped");
        return;
    }

    XMEMSET(&resp, 0, sizeof(resp));
    resp.status = WC_TSP_PKISTATUS_GRANTED;
    resp.token = token;
    resp.tokenSz = tokenSz;

    /* 2162 idx0 true, idx1 false: cm==NULL, ret==0 reaches this decision.
     * Also 2179/2188 idx0/idx1 true rows: tstInfo!=NULL, contentSz>0. */
    XMEMSET(&tstOut, 0, sizeof(tstOut));
    ret = TspResponse_Verify(&resp, NULL, 0, NULL, &tstOut);
    if (ret != 0) {
        WB_NOTE("TspResponse_Verify(cm==NULL, tstInfo!=NULL) baseline misbehaved");
        wb_fail = 1;
    }

    /* 2179/2188 idx1 false row: tstInfo==NULL, ret==0. */
    ret = TspResponse_Verify(&resp, NULL, 0, NULL, NULL);
    if (ret != 0) {
        WB_NOTE("TspResponse_Verify(tstInfo==NULL) baseline misbehaved");
        wb_fail = 1;
    }

    /* 2162 idx0 false: an earlier failure (bad status) short-circuits before
     * the cm check - cm's value does not matter here (never evaluated). */
    {
        TspResponse badResp = resp;
        badResp.status = 99;
        ret = TspResponse_Verify(&badResp, NULL, 0, NULL, NULL);
        if (ret == 0) {
            WB_NOTE("TspResponse_Verify bad-status case unexpectedly succeeded");
            wb_fail = 1;
        }
    }

    /* 2162 idx1 true: ret==0 with cm != NULL. An empty (no trust anchors)
     * certificate manager still exercises the decision's TRUE row; the
     * ensuing chain verify is expected to fail (untrusted signer), which is
     * Tsp_VerifyCertChain()'s own return value, not this decision's. */
    cm = wolfSSL_CertManagerNew();
    if (cm == NULL) {
        WB_NOTE("wolfSSL_CertManagerNew failed; cm!=NULL row skipped");
    }
    else {
        XMEMSET(&tstOut, 0, sizeof(tstOut));
        ret = TspResponse_Verify(&resp, NULL, 0, cm, &tstOut);
        if (ret == 0) {
            WB_NOTE("TspResponse_Verify(cm, untrusted signer) unexpectedly succeeded");
            wb_fail = 1;
        }
        wolfSSL_CertManagerFree(cm);
    }

    WB_NOTE("TspResponse_Verify cm!=NULL MC/DC pair exercised (2162)");
}
#else
static void wb_response_verify_cm(void) { WB_NOTE("HAVE_PKCS7/WOLFSSL_TSP_RESPONDER/WOLFSSL_TSP_VERIFIER/RSA/SHA256 unavailable; TspResponse_Verify cm rows skipped"); }
#endif

int main(void)
{
    setvbuf(stdout, NULL, _IONBF, 0);
    printf("tsp.c fault/argument-guard white-box MC/DC supplement\n");

    wb_gentime_as_time_guards();
    wb_set_nonce_extra();
    wb_set_from_request_guards();
    wb_check_request_extra();
    wb_sign_with_pkcs7_certsz();
    wb_sign_with_pkcs7_alloc_sweep();
    wb_check_tsa_name_extra();
    wb_check_signer_cert_extra();
    wb_response_verify_cm();

    printf("done (%s)\n", wb_fail ? "with skips" : "ok");
    /* Always return 0: a nonzero exit makes the campaign discard the whole
     * variant's coverage, including the parts that did succeed. */
    (void)wb_fail;
    return 0;
}

#endif /* WOLFSSL_TSP */
