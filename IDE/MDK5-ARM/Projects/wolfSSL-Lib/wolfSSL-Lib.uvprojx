# Keil uVision project wolfSSL-Lib.uvprojx, settings and files
target wolfSSL-Lib (ARM-ADS)
  device: STM32F207IG STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M3") CLOCK(120000000) ELITTLE
  output: wolfSSL (library)
  c flags: Optim=4
  c define: HAVE_CONFIG_H   MDK_CONF_WOLFLIB WOLFSSL_USER_SETTINGS
  c misc: --diag_suppress=1293
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Configuration
    ./RTE/wolfSSL/: config-Crypt.h config-wolfSSL.h user_settings.h
software components: CMSIS:CORE 4.1.0, CMSIS:RTOS:Keil RTX 4.78.0, Network:CORE 7.0.0, Network:Interface:ETH 7.0.0, Network:Service:DNS Client 7.0.0, Network:Socket:BSD 7.0.0, Network:Socket:TCP 7.0.0, Network:Socket:UDP 7.0.0, CMSIS Driver:Ethernet MAC 2.01, CMSIS Driver:Ethernet PHY:ST802RT1 6.00, Device:STM32Cube Framework:Classic 1.0.1, Device:STM32Cube HAL:Common 1.0.1, Device:STM32Cube HAL:Cortex 1.0.1, Device:STM32Cube HAL:DMA 1.0.1, Device:STM32Cube HAL:ETH 1.0.1, Device:STM32Cube HAL:GPIO 1.0.1, Device:STM32Cube HAL:RCC 1.0.1, Device:STM32Cube HAL:SRAM 1.0.1, Device:Startup 2.0.1, wolfSSL:wolfCrypt:CORE 3.6.6, wolfSSL:wolfSSL:Core 3.6.6
