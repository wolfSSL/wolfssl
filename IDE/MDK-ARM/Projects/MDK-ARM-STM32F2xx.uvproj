# Keil uVision project MDK-ARM-STM32F2xx.uvproj, settings and files
target MDK-RTX-TCP-FS (ARM-ADS)
  device: STM32F207IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: STM32F2xx-MDK-RTX-TCP-FS
  c flags: Optim=1
  c define: HAVE_CONFIG_H CYASSL_STM32F2xx __DBG_ITM __RTX MDK_CONF_RTX_TCP_FS
  c include: ..\MDK-ARM\wolfSSL;..\..\..\; .\; C:\Keil_v5\ARM\RV31\INC
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group wolfSSL Apps
    ../../../testApps/client/: client.c
    ../MDK-ARM/wolfSSL/: shell.c main.c
    ../../../testApps/server/: server.c
    ../../../wolfcrypt/test/: test.c
    ../../../wolfcrypt/benchmark/: benchmark.c
    ../../../testApps/echoclient/: echoclient.c
    ../../../testApps/echoserver/: echoserver.c
  group MDK-ARM
    c:/Keil_v5/ARM/RV31/LIB//: RTX_CM3.lib
    c:/Keil_v5/ARM/RL/TCPnet/Drivers/: ETH_STM32F2xx.c
    c:/Keil_v5/ARM/RV31/LIB/: TCPD_CM3.lib TCP_CM3.lib
    C:/Keil_v5/ARM/Startup/ST/STM32F2xx/: system_stm32f2xx.c
    C:/Keil_v5/ARM/Boards/Keil/MCBSTM32F200/RL/FlashFS/SD_File/: SDIO_STM32F2xx.c
    C:/Keil_v5/ARM/RV31/LIB/: FS_CM3.lib
  group Configuration
    C:/Keil_v5/ARM/Boards/Keil/MCBSTM32F200/RL/TCPnet/Http_demo/: Net_Config.c RTX_Config.c Net_Debug.c startup_stm32f2xx.s
    ../MDK-ARM/wolfSSL/: config.h config-FS.h config-RTX-TCP-FS.h config-BARE-METAL.h config-WOLFLIB.h
    C:/Keil_v5/ARM/Boards/Keil/MCBSTM32F200/RL/FlashFS/SD_File/: File_Config.c
  group wolfSSL-MDK
    ../MDK-ARM/wolfSSL/: Retarget.c time-CortexM3-4.c time-dummy.c wolfssl_MDK_ARM.c
    C:/Keil_v5/ARM/Boards/Keil/MCBSTM32F200/Blinky_ULp/: Serial.c
  group wolfSSL-Lib
    ./wolfSSL-lib/: wolfSSL.lib
target MDK-FS (ARM-ADS)
  device: STM32F207IG STMicroelectronics
  cpu: as above
  output: STM32F2xx-MDK-FS
  c flags: Optim=1
  c define: HAVE_CONFIG_H WOLFSSL_STM32F2xx __DBG_ITM MDK_CONF_FS
  c include: ..\MDK-ARM\wolfSSL;..\MDK-ARM\inc;..\..\..\
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
target MDK-BARE-METAL (ARM-ADS)
  device: STM32F207IG STMicroelectronics
  cpu: as above
  output: STM32F2xx-BARE-METAL
  c flags: Optim=1
  c define: HAVE_CONFIG_H  CYASSL_STM32F2xx  __DBG_ITM MDK_CONF_BARE_METAL
  c include: ..\MDK-ARM\wolfSSL;..\MDK-ARM\inc;..\..\..\
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
