# IAR project wolfcrypt_lib.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: WOLFSSL_USER_SETTINGS
  ICCARM.IExtraOptions: --diag_warning Pa089; --diag_suppress Pa089; --diag_warning Pe231; --diag_suppress Pe231
  ICCARM.CCIncludePath2: ..\..\..\..\..\; ..\embOS_SAMV71_XULT_user_settings
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: wolfcrypt_lib.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group wolfcrypt_sources
    ../../../../../wolfcrypt/src/: aes.c asn.c chacha.c chacha20_poly1305.c coding.c des3.c dh.c dsa.c ecc.c hash.c kdf.c hmac.c md4.c md5.c memory.c misc.c poly1305.c pwdbased.c rabbit.c random.c rsa.c sha.c sha256.c sha512.c tfm.c wc_encrypt.c wc_port.c
