# IAR project client.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MB9BF618T Fujitsu MB9BF618T
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CYASSL_IAR_ARM
  ICCARM.CCIncludePath2: ..\..\CyaSSL; ..\..\..\..\examples\client; ..\..\..\..; ..\..\..\..\..\mb9bf61xt_ethernet_lwip_v12\example\source\lwip1_4_0\src\include; C:\ROOT\CyaSSL-Release\LwIP-Release\mb9bf61xt_ethernet_lwip_v12\example\source\fm3_adaption; C:\ROOT\CyaSSL-Release\LwIP-Release\mb9bf61xt_ethernet_lwip_v12\example\source\lwip1_4_0\port; C:\ROOT\CyaSSL-Release\LwIP-Release\mb9bf61xt_ethernet_lwip_v12\example\source\lwip1_4_0\src\include\ipv4
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: CyaSSL-Full.srec
  ILINK.IlinkOutputFile: CyaSSL-Full.out
  ILINK.IlinkIcfFile: CyaSSL-Full.icf
  ILINK.IlinkAdditionalLibs: ..\CyaSSL-Lib\Debug\Exe\CyaSSL-Lib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  group Apps
    ../../../../examples/client/: client.c
    ../../CyaSSL/: tcp-conn-nb.c
