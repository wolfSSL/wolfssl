# IAR project wolfSSL-Lib.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C129XNCZAD TexasInstruments TM4C129XNCZAD
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: WOLFSSL_USER_SETTINGS
  ICCARM.CCDiagSuppress: Pa050,Pa089,Pe177
  ICCARM.CCIncludePath2: ..\..\..\..; ..
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: CyaSSL-Full.srec
  ILINK.IlinkOutputFile: CyaSSL-Full.out
  ILINK.IlinkIcfFile: CyaSSL-Full.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group Config
    ../../../../wolfssl/wolfcrypt/: settings.h
    ../: user_settings.h
  group wolfCrypt
    ../../../../wolfcrypt/src/: aes.c arc4.c asm.c asn.c blake2b.c camellia.c chacha.c chacha20_poly1305.c coding.c compress.c curve25519.c des3.c dh.c dsa.c ecc.c ecc_fp.c ed25519.c error.c fe_operations.c ge_operations.c hash.c hc128.c hmac.c integer.c logging.c md2.c md4.c md5.c memory.c misc.c pkcs7.c poly1305.c pwdbased.c rabbit.c random.c ripemd.c rsa.c sha.c sha256.c sha512.c tfm.c wc_port.c
  group wolfSSL
    ../../../../src/: crl.c internal.c io.c keys.c ocsp.c sniffer.c ssl.c tls.c
